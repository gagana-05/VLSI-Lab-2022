* SPICE3 file created from gagana_joshua.ext - technology: scmos

.include ./t14y_tsmc_025_level3.txt

M1000 out in Vdd Vdd cmosp w=20u l=2u ad=100 pd=50 as=100 ps=50
M1001 out in Vss Gnd cmosn w=10u l=2u ad=50 pd=30 as=50 ps=30
C0 Vss Gnd 4.98fF
C1 out Gnd 2.07fF
C2 in Gnd 5.47fF

* power sources excitation etc.
* v_instance_name posive_node negetive_node value
v_dd Vdd 0 5
v_0 Vss 0 0
v_in in 0 pulse(0 5 0 0.1n 0.1n 50n 100n)

.control
tran 0.1n 100n

setplot tran1
plot -v_dd#branch
plot in out
plot out

.endc
